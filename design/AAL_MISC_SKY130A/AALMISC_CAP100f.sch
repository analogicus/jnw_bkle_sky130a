v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 90 70 3 0 {name=p0 lab=A}
C {devices/iopin.sym} 90 130 1 0 {name=p1 lab=B}
C {sky130_fd_pr/cap_mim_m3_1.sym} 90 100 0 0 {name=C1
L=7 W=7
 
}
