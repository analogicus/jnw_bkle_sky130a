v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {cborder/border_s.sym} 1400 -200 0 0 {
user="bkle"
company="bkle"}
C {JNW_BKLE_SKY130A/COMP.sym} 890 -640 0 0 {name=U1}
