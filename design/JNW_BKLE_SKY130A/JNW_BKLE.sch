v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {cborder/border_s.sym} 1390 -200 0 0 {
user="bkle"
company="bkle"}
C {JNW_BKLE_SKY130A/COMP.sym} 810 -620 0 0 {name=x1}
