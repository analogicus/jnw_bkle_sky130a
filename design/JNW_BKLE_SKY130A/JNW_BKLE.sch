v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {cborder/border_s.sym} 1420 -240 0 0 {
user="bkle"
company="bkle"}
C {JNW_BKLE_SKY130A/OTA_Manuel.sym} 1150 -650 0 0 {name=xU1}
